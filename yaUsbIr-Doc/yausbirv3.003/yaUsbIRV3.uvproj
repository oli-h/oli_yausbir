# Keil uVision project yaUsbIRV3.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F387 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0x7FFF) CLOCK(48000000)
  output: yaUsbIrV3 +hex
  c flags: Optimize=8 SizeSpeed=1
  c misc: DB SB OE Compact OT(11,Speed)
  asm misc: XR,GEN,DB,EP,NOMOD51
  group Source
    ./: USB_Standard_Requests.c flash.c ir.c sio.c USB_Descriptor.c USB_HID_Requests.c USB_ISR.c USB_Main.c io.c
  group Include
    ./: USB_Configuration.h USB_Descriptor.h USB_HID_Requests.h USB_ISR.h USB_Main.h USB_Standard_Requests.h USB_Register.h common.h sio.h ir.h flash.h io.h
  group ASM
    ./: fill.asm
  group Dok
    ./: ReadMe.txt cleanup.bat irsend_cmd.txt
    ./dok/: Manchester- & Biphasedecoder.txt
